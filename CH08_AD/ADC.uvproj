# Keil uVision project ADC.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82G516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(12000000)
  output: ADC +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: ADC6.C
